*** Title: "D:\L_1\LR_1\LR_SSHMT_!\LR_2_SH\simulation\tb_nand3\netlistLR_2_SH.cir"
*** Generated by:  Symica
*** © 2009-2014 Symica. All rights reserved. (www.symica.com)
*** Generated for: SymSpice
*** Generated on:  Wed Nov 05 09:48:57 2025
*******************************************************************
*** This is a root file of the project
*******************************************************************

simulator lang=local

global gnd vdd!

include "C:\Users\8221452\Desktop\models\mmapr_mos.lib"
