*** Title: "D:\L_1\LR_1\LR_SSHMT_!\LR_2_SH\LR_2_Sch\simulation\Z_3\netlistLR_2_Sch.cir"
*** Generated by:  Symica
*** © 2009-2014 Symica. All rights reserved. (www.symica.com)
*** Generated for: SymSpice
*** Generated on:  Sat Oct 18 14:30:20 2025
*******************************************************************
*** This is a root file of the project
*******************************************************************

simulator lang=local

global gnd

include "C:\Users\8221452\Desktop\models\bjt.lib"
