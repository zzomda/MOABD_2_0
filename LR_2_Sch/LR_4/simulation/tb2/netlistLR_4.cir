*** Title: "D:\L_1\LR_1\LR_SSHMT_!\LR_2_SH\LR_2_Sch\LR_4\simulation\tb2\netlistLR_4.cir"
*** Generated by:  Symica
*** © 2009-2014 Symica. All rights reserved. (www.symica.com)
*** Generated for: SymSpice
*** Generated on:  Wed Oct 22 10:43:07 2025
*******************************************************************
*** This is a root file of the project
*******************************************************************

simulator lang=local

global gnd vdd!

include "C:\Users\8221452\Desktop\models\mmapr_mos.lib"
