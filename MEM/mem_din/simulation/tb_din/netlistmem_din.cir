*** Title: "E:\Íîâàÿ ïàïêà\LR_2_SH\MEM\mem_din\simulation\tb_din\netlistmem_din.cir"
*** Generated by:  Symica
*** © 2009-2014 Symica. All rights reserved. (www.symica.com)
*** Generated for: SymSpice
*** Generated on:  Sat Dec 20 15:25:39 2025
*******************************************************************
*** This is a root file of the project
*******************************************************************

simulator lang=local

global gnd

include "E:\Symica Free\lib\models\mos.lib"
include "E:\Symica Free\lib\models\BD234.LIB"
