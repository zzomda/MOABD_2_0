*** Title: "E:\Íîâàÿ ïàïêà\LR_2_SH\MEM\simulation\tb_mem\netlistMEM.cir"
*** Generated by:  Symica
*** © 2009-2014 Symica. All rights reserved. (www.symica.com)
*** Generated for: SymSpice
*** Generated on:  Wed Dec 03 00:08:26 2025
*******************************************************************
*** This is a root file of the project
*******************************************************************

simulator lang=local

global gnd vdd!

include "E:\Symica Free\lib\models\mos.lib"
