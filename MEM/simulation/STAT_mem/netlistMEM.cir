*** Title: "E:\Íîâàÿ ïàïêà\LR_2_SH\MEM\simulation\STAT_mem\netlistMEM.cir"
*** Generated by:  Symica
*** © 2009-2014 Symica. All rights reserved. (www.symica.com)
*** Generated for: SymSpice
*** Generated on:  Tue Dec 02 21:53:42 2025
*******************************************************************
*** This is a root file of the project
*******************************************************************

simulator lang=local

global gnd vdd! vss!

include "E:\Symica Free\lib\models\cmos.lib"
include "E:\Symica Free\lib\models\mos.lib"
