*** Title: "E:\Íîâàÿ ïàïêà\LR_2_SH\MEM\mem_din\simulation\din\netlistmem_din.cir"
*** Generated by:  Symica
*** © 2009-2014 Symica. All rights reserved. (www.symica.com)
*** Generated for: SymSpice
*** Generated on:  Wed Dec 17 10:26:56 2025
*******************************************************************
*** This is a root file of the project
*******************************************************************

simulator lang=local

global gnd

include "E:\Symica Free\lib\models\cmos.lib"
