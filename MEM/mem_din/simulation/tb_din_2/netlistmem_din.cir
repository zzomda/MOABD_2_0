*** Title: "E:\Íîâàÿ ïàïêà\LR_2_SH\MEM\mem_din\simulation\tb_din_2\netlistmem_din.cir"
*** Generated by:  Symica
*** © 2009-2014 Symica. All rights reserved. (www.symica.com)
*** Generated for: SymSpice
*** Generated on:  Sat Dec 20 15:44:40 2025
*******************************************************************
*** This is a root file of the project
*******************************************************************

simulator lang=local

global gnd

include "E:\Symica Free\lib\models\mos.lib"
